// 031.cpp: 定义控制台应用程序的入口点。
//

#include "stdafx.h"
#include<stdio.h>
#include<string.h>
#include<stdlib.h>

struct  Node
{
	char name[32];
	Node  *next;
};


//创建一条链表,拥有N个节点，尾插法
Node  *   CreateList(int  N)
{
	Node  *pHead = NULL;
	Node  *pTail = NULL;

	for (size_t i = 0; i < N; i++)
	{
		Node  * pNode = (Node *)malloc(sizeof(Node));
		sprintf(pNode->name, "学生%d", i + 1);
		pNode->next = NULL;

		if (pHead == NULL)//如果是第一个节点
		{
			pHead = pNode;
		}
		else
		{
			pTail->next = pNode;
		}
		pTail = pNode;
	}

	return  pHead;//返回链表头结点的指针
}


//打印一条链表
void  PrintList(Node  *pHead)
{
	while (pHead != NULL)
	{
		printf("%s    ", pHead->name);
		pHead = pHead->next;//pHead的改变不影响实参,因为是参数的拷贝
	}
	printf("\n");
}

//实现单向链表的反转
Node  *     ReverseList(Node  *pHead)
{
	Node *pLast = NULL;//实时保存前一个节点的地址

	Node *pCur = pHead;//指向遍历的当前节点
	while (pCur) //不使用pCur，直接使用pHead也可以
	{
		Node *pNext = pCur->next;//保存下一个节点的地址，因为下面一句代码会覆盖next的值

		pCur->next = pLast;//让当前节点的next指向前一个，反转当前节点
		
		pLast = pCur;//保存当前节点为下一次遍历做准备
		
		pCur = pNext ;//继续向后遍历
	}

	return   pLast;

}
  

int main()
{
	Node  *pHead = CreateList(5);
	PrintList(pHead);

	pHead = ReverseList(pHead);
	PrintList(pHead);
  
	return 0;
}

